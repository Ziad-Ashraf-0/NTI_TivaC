# Keil uVision project NTI_TivaC.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NTI_TivaC
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\CONFIG;.\MCAL;.\LIB;.\MCAL\DIO\Inc;.\MCAL\IntCtrl\Inc;.\MCAL\PORT\Inc;.\HAL\BUTTON\Inc;.\HAL\LED\Inc;.\MCAL\SysTick\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MCAL
    ./MCAL/PORT/: Port_prg.c
    ./MCAL/IntCtrl/: IntCtrl_prg.c
    ./MCAL/DIO/: Dio_prg.c
    ./MCAL/SysTick/: SysTick_prg.c
  group APP
    ./APP/: main.c
  group HAL
    ./HAL/LED/: Led_prg.c
    ./HAL/BUTTON/: Button_prg.c
  group CONFIG
    ./CONFIG/: IntCtrl_Lcfg.c Port_Lcfg.c Led_Lcfg.c Button_Lcfg.c SysTick_Lcfg.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
